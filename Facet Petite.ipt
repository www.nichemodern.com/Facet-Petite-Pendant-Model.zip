# Autodesk Inventor part: Facet Petite
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2022-09
Part Number: Facet Petite
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Facet Petite
Author: Administrator
## Design history (mm, degrees)
feature "Glass-Facet Petite"
body "Solid1"
